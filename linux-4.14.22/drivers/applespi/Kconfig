## linux-4.14.22/drivers/applespi/Kconfig
```kconfig
config APPLE_SPI
	tristate "Apple SPI keyboard driver"
	depends on APPLE_GMUX
	help
	  Apple SPI keyboard driver for Macbook 2016 and newer
```
